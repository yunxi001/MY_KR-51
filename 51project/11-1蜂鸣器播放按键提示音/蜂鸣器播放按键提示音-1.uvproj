# Keil uVision project 蜂鸣器播放按键提示音-1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 蜂鸣器播放按键提示音-1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Delay.c Ket.c Nixie.c 蜂鸣器播放按键提示音-1.c Key.h Nixie.h Delay.h buzzer.c buzzer.h
