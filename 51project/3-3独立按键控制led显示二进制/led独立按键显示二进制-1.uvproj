# Keil uVision project led独立按键显示二进制-1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: led独立按键显示二进制-1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: led独立按键显示二进制-1.c
