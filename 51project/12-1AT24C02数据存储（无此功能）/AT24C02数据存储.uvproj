# Keil uVision project AT24C02数据存储.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: AT24C02数据存储 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Delay.c Ket.c LCD1602.c main.c Key.h LCD1602.h Delay.h AT24c02.c I2C.c I2C.h
