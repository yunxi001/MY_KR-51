# Keil uVision project 定时器时钟-1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 定时器时钟-1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Delay.c LCD1602.c 定时器时钟-1.c LCD1602.h Delay.h Timer0.c Timer0.h
