# Keil uVision project 蜂鸣器播放音乐-1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 蜂鸣器播放音乐-1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Delay.c Delay.h Timer0.c Timer0.h 蜂鸣器播放音乐-1.c
