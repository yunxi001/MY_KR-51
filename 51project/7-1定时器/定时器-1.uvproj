# Keil uVision project 定时器-1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 定时器-1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 定时器-1.c Timer0.c Timer0.h Ket.c Key.h Delay.c Delay.h
