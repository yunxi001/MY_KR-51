# Keil uVision project 秒表.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 秒表 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Timer0.h Timer0.c LCD1602.h LCD1602.c Key.h Ket.c Delay.h Delay.c main.c I2C.c AT24c02.c AT24c02.h I2C.h
