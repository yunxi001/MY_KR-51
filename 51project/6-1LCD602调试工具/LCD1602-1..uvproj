# Keil uVision project LCD1602-1..uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LCD1602-1. +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
    $TC_ROOT$/../../../KR-51/51project/6-1LCD602调试工具/: LCD1602.c LCD1602.h
