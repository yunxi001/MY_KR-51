# Keil uVision project LCD1602调试工具-1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LCD1602调试工具-1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: LCD1602.c LCD1602调试工具-1.c LCD1602.h
    ../5-1模块化编程/: Delay.c Delay.h
