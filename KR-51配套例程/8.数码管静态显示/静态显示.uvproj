# Keil uVision project 静态显示.uvproj, settings and files
target Target 1 (MCS-51)
  device: 89C52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: 静态显示 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 静态显示.c
