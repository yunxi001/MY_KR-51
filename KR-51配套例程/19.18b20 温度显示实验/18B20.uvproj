# Keil uVision project 18B20.uvproj, settings and files
target 对象 1 (MCS-51)
  device: (null) (null)
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(24000000)
  output: 18B20 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源文件组 1
    ./: 18B20.C
